# Keil uVision project P001.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P001 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Top;.\Middle;.\Low;.\Driver;.\library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c define.c init.c
  group Middle
    ./Middle/: led.c printf.c key.c
  group Low
    ./Low/: gpio_def.c delay.c usart1.c iwdg.c
  group Driver
    ./Driver/: misc.c stm32f10x_it.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_iwdg.c
  group Library
    ./library/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.3.0
